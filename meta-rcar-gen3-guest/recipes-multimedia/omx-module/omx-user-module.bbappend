DEPENDS_remove = " \
    kernel-module-uvcs-drv \
    kernel-module-mmngr \
    kernel-module-vspmif \
    kernel-module-vspm kernel-module-vsp2driver \
"

